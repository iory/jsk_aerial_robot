Commit message: Update model for vim4 version

File: robots/mini_quadrotor/urdf/draugas.urdf (robot description, URDF)
Before this commit: robot draugas, 8 links, 7 joints
Links:
- link main_body: mass 0.63218 -> 0.714108321948334
